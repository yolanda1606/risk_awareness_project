Commit message: tested in lab

File: src/panda_ign_moveit2/panda_description/urdf/panda.urdf (robot description, URDF)
Before this commit: robot panda, 14 links, 13 joints
Links:
- link panda_hand_tcp: mass None -> 0.01
- link panda_link8: mass None -> 0.01
